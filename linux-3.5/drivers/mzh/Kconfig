## linux-3.5/drivers/mzh/Kconfig
```kconfig
config MZH_KTHREAD
	tristate "my kthread"
	default y

config MZH_LIST
	tristate "list theory"
	default y
```
